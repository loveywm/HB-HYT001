# Keil uVision project msOS-Stm32.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: HB-HYT001 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SourceFile\App;..\SourceFile\System;..\SourceFile\System\Device;..\SourceFile\System\Device\Drive;..\SourceFile\System\Device\Drive\CMSIS;..\SourceFile\System\Device\Drive\LIB\inc;..\SourceFile\System\OS;..\SourceFile\System\OS\msOS;..\SourceFile\System\GUI;C:\Keil\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --libpath=C:\Keil\ARM\ARMCC\lib
  group App
    ../SourceFile/App/: app.c uiLCD_12864.c uiFont.c KeyBoard.c Voice.c uiPross.c password.c SFlashApi.c Uart.c load.c Encoder.c Call.c
  group System
    ../SourceFile/System/: system.h system.c
  group System.Device
    ../SourceFile/System/Device/: device.c device.h device_key.c device_rtc.c device_timer.c device_io.c device_adc.c device_usart.c device_systick.c device_lcd_12864.c device_w25q64.c device_tim.c device_encoder.c
  group System.Device.Drive
    ../SourceFile/System/Device/Drive/: drive.h stm32f10x_it.c
  group System.Device.Drive.Cmsis
    ../SourceFile/System/Device/Drive/CMSIS/: core_cm3.c system_stm32f10x.c
    ../SourceFile/System/Device/Drive/CMSIS/STARTUP/: startup_stm32f10x_hd.s
  group System.Device.Drive.Lib
    ../SourceFile/System/Device/Drive/LIB/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_tim.c
